<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\F103C8_USBFLASH.ewp</path>
  </project>
  <batchBuild />
</workspace>
